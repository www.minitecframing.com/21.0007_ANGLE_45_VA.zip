# Autodesk Inventor assembly: 21.0007 Angle 45 VA
## iProperties
Created: 2009-12
Part Number: 21.0007 Angle 45 VA
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
